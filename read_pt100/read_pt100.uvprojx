# Keil uVision project read_pt100.uvprojx, settings and files
target GPIO (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F334R8Tx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: read_pt100 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F334X8
  c include: ..\..\GPIO;..\read_pt100;..\project;..\lib\STM32F30x_StdPeriph_Driver\inc;..\lib\STM32F30x_StdPeriph_Driver\src;..\lib\CMSIS\Include;..\lib\CMSIS\Device\ST\STM32F30x\Include;..\lib\STM32F30x_StdPeriph_Driver\src;..\lib\CMSIS\Device\ST\STM32F30x\Source\Templates\arm;..\lib\CMSIS\Device\ST\STM32F30x\Source\Templates
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group lib
    ../lib/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_exti.c stm32f30x_gpio.c stm32f30x_misc.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c
    ../lib/STM32F30x_StdPeriph_Driver/inc/: stm32f30x_adc.h stm32f30x_exti.h stm32f30x_gpio.h stm32f30x_misc.h stm32f30x_pwr.h stm32f30x_syscfg.h stm32f30x_tim.h stm32f30x_usart.h
    ../lib/CMSIS/Device/ST/STM32F30x/Source/Templates/: system_stm32f30x.c
    ../lib/CMSIS/Device/ST/STM32F30x/Source/Templates/arm/: startup_stm32f334x8.s
  group user
    ../lib/CMSIS/Device/ST/STM32F30x/Include/: system_stm32f30x.h stm32f30x.h
    ../project/: main.h stm32f30x_conf.h stm32f30x_it.c stm32f30x_it.h
    ../lib/STM32F30x_StdPeriph_Driver/src/: SysTick_Delay.c
    ../lib/STM32F30x_StdPeriph_Driver/inc/: SysTick_Delay.h
    ./: main.c
